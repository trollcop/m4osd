# Keil uVision project m4osd.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F303CC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: cloneflight +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F30X,HSE_VALUE=12000000
  c misc: --c99
  c include: lib\CMSIS;lib\STM32F30x_StdPeriph_Driver\inc;lib\STM32_USB-FS-Device_Driver\inc;lib\CoOS;src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\m4osd.sct
  group CMSIS
    ./lib/CMSIS/: system_stm32f30x.c startup_stm32f30x.s stm32f30x.h
  group STM32F30x_StdPeriph_Driver
    ./lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group CoOS
    ./lib/CoOS/: arch.c core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c port.c queue.c sem.c serviceReq.c task.c time.c timer.c OsConfig.h
  group App
    ./src/: board.h main.c
  group STM32_USB-FS-Device_Driver
    ./lib/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
